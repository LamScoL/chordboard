## config/boards/shields/chordboard/Kconfig.shield
```kconfig
config SHIELD_CHORDBOARD
	def_bool $(shields_list_contains, ChordBoard)

CONFIG_ZMK_HID_REPORT_TYPE_NKRO=y
```
